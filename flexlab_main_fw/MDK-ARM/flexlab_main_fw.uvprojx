# Keil uVision project flexlab_main_fw.uvprojx, settings and files
target flexlab_main_fw (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: flexlab_main_fw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,FT5206_TOUCH_DRIVER_no
  c misc: --locale=english
  c include: ../Inc;../Src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/touch;../Drivers/BSP/W25QXX;../lens;../middlewares/st/touchgfx/framework/include;../src/generated/fonts/include;../src/generated/gui_generated/include;../src/generated/images/include;../src/generated/texts/include;../src/generated/videos/include;../src/gui/include
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: flexlab_main_fw\flexlab_main_fw.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma2d.c fmc.c ltdc.c rtc.c spi.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp STM32TouchController.cpp STM32DMA.cpp OSWrappers.cpp TouchGFXGPIO.cpp app_touchgfx.c usart.c stm32f4xx_it.c nema_hal_threadx.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP
    ../Drivers/BSP/touch/: ctiic.c ft5206.c gt9147.c
    ../Drivers/BSP/W25QXX/: w25qxx.c
  group gui
    ../src/gui/src/containers/: custom_slider_handler_off.cpp custom_slider_handler_on.cpp double_slider.cpp layer_info.cpp scroll_wheel_text.cpp scroll_wheel_text_mid.cpp scroll_wheel_text_small.cpp scroll_wheel_text_small_mid.cpp start_seen.cpp
    ../src/gui/src/common/: frontendapplication.cpp
    ../src/gui/src/lens/: lens.cpp
    ../src/gui/src/model/: model.cpp
    ../src/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../src/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
    ../src/gui/src/screen3_screen/: screen3presenter.cpp screen3view.cpp
    ../src/gui/src/start_screen_screen/: start_screenpresenter.cpp start_screenview.cpp
  group generated
    ../src/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_stxihei_ttf_12_4bpp_0.cpp font_stxihei_ttf_12_4bpp_4.cpp font_stxihei_ttf_20_4bpp_0.cpp font_stxihei_ttf_20_4bpp_10.cpp font_stxihei_ttf_20_4bpp_11.cpp font_stxihei_ttf_20_4bpp_12.cpp font_stxihei_ttf_20_4bpp_13.cpp font_stxihei_ttf_20_4bpp_14.cpp font_stxihei_ttf_20_4bpp_15.cpp font_stxihei_ttf_20_4bpp_16.cpp font_stxihei_ttf_20_4bpp_17.cpp font_stxihei_ttf_20_4bpp_18.cpp font_stxihei_ttf_20_4bpp_19.cpp font_stxihei_ttf_20_4bpp_4.cpp font_stxihei_ttf_30_4bpp_0.cpp font_stxihei_ttf_30_4bpp_10.cpp font_stxihei_ttf_30_4bpp_11.cpp font_stxihei_ttf_30_4bpp_12.cpp font_stxihei_ttf_30_4bpp_13.cpp font_stxihei_ttf_30_4bpp_14.cpp font_stxihei_ttf_30_4bpp_15.cpp font_stxihei_ttf_30_4bpp_16.cpp font_stxihei_ttf_30_4bpp_17.cpp font_stxihei_ttf_30_4bpp_18.cpp font_stxihei_ttf_30_4bpp_19.cpp font_stxihei_ttf_30_4bpp_9.cpp font_stxihei_ttf_50_4bpp_0.cpp font_stxihei_ttf_50_4bpp_11.cpp font_stxihei_ttf_50_4bpp_13.cpp font_stxihei_ttf_50_4bpp_15.cpp font_stxihei_ttf_50_4bpp_4.cpp font_stxihei_ttf_70_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_stxihei_ttf_12_4bpp.cpp kerning_stxihei_ttf_20_4bpp.cpp kerning_stxihei_ttf_30_4bpp.cpp kerning_stxihei_ttf_50_4bpp.cpp kerning_stxihei_ttf_70_4bpp.cpp table_stxihei_ttf_12_4bpp.cpp table_stxihei_ttf_20_4bpp.cpp table_stxihei_ttf_30_4bpp.cpp table_stxihei_ttf_50_4bpp.cpp table_stxihei_ttf_70_4bpp.cpp unmappeddatafont.cpp
    ../src/generated/images/src/: bitmapdatabase.cpp image_background2.cpp image_background_modal_l.cpp image_background_modal_s.cpp image_button_press.cpp image_button_press_medium.cpp image_button_relase.cpp image_button_relase_medium.cpp image_button_toggle_off.cpp image_button_toggle_off_medium.cpp image_button_toggle_on.cpp image_button_toggle_on_medium.cpp image_icon_back.cpp image_icon_back_w.cpp image_icon_f_clock.cpp image_icon_flower.cpp image_icon_grass.cpp image_icon_light.cpp image_icon_mixer.cpp image_icon_recycle.cpp image_icon_standby.cpp image_icon_temp.cpp image_icon_vent.cpp image_icon_zoom.cpp image_icon_zoom_w.cpp image_layer_1_indicate.cpp image_layer_2_indicate.cpp image_layer_3_indicate.cpp image_lens_image.cpp image_main_logo_s.cpp image_slider3_vertical_round_fill_blue.cpp image_slider3_vertical_round_fill_farred.cpp image_slider3_vertical_round_fill_red.cpp image_slider3_vertical_round_fill_white.cpp image_slider3_vertical_round_nob_blue.cpp image_slider_bar.cpp image_slider_handle.cpp
    ../src/generated/gui_generated/src/containers/: custom_slider_handler_offbase.cpp custom_slider_handler_onbase.cpp double_sliderbase.cpp layer_infobase.cpp scroll_wheel_text_midbase.cpp scroll_wheel_text_small_midbase.cpp scroll_wheel_text_smallbase.cpp scroll_wheel_textbase.cpp start_seenbase.cpp
    ../src/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../src/generated/images/src/__designer/: image_blue_slider_vertical_small_indicators_slider3_vertical_round_nob.cpp image_blue_slider_vertical_small_slider3_vertical_round_back.cpp
    ../src/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../src/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../src/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
    ../src/generated/gui_generated/src/screen3_screen/: screen3viewbase.cpp
    ../src/generated/gui_generated/src/start_screen_screen/: start_screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
